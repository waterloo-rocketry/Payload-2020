# Repository waterloo-rocketry/Payload-2020 (continued)

## KiCad design mama_board/mama_board.kicad_pcb (continued)

Parts:
C3: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C9, C10: 26pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C11, C13, C14: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: 156120RS75000; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D4: 150120BS75000; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D5: QBLP650-IW; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: Programming Header; PinHeader_1x05_P2.54mm_Vertical
J10: Conn_01x06_Female; connector_Harwin_M80-5000642
R4, R5, R9: 500; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6, R10: 100; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U5: PIC18F26K83; SOIC-28W_7.5x18.7mm_P1.27mm
U10: MCP2562-E/SN; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 12MHz; Crystal_HC49-4H_Vertical

Connections:
+5V: C11.2, C13.1, C14.1, J1.2, R10.1, U5.20 (VDD), U10.3 (VDD), U10.5 (Vio); also elsewhere on the board
/Comparitor Circuits/INTERRUPT_1: U5.3 (RA1); also elsewhere on the board
/Comparitor Circuits/INTERRUPT_2: U5.4 (RA2); also elsewhere on the board
/Comparitor Circuits/INTERRUPT_3: U5.2 (RA0); also elsewhere on the board
/DET_ADC_1: U5.16 (RC5); also elsewhere on the board
/DET_ADC_2: U5.17 (RC6); also elsewhere on the board
/DET_ADC_3: U5.18 (RC7); also elsewhere on the board
/Microcontroller/CANH: J10.4, U10.7 (CANH)
/Microcontroller/CANL: J10.5, U10.6 (CANL)
/Microcontroller/ICSPCLK: J1.5, U5.27 (RB6/ICSPCLK)
/Microcontroller/ICSPDAT: J1.4, U5.28 (RB7/ICSPDAT)
/Microcontroller/MCLR: C3.1, J1.1, R6.2, R10.2
/Microcontroller/OSC1: C9.1, U5.9 (RA7/OSC1), Y1.1
/Microcontroller/OSC2: C10.1, U5.10 (RA6/OSC2), Y1.2
/Microcontroller/PIC_RX: U5.12 (RC1), U10.4 (RXD)
/Microcontroller/PIC_TX: U5.11 (RC0), U10.1 (TXD)
GND: C3.2, C9.2, C10.2, C11.1, C13.2, C14.2, D3.1 (K), D4.1 (K), D5.1 (K), J1.3, J10.3, U5.8 (VSS), U5.19 (VSS), U10.2 (VSS), U10.8 (STBY); also elsewhere on the board
unnamed: D3.2 (A), R4.2
unnamed: D4.2 (A), R5.2
unnamed: D5.2 (A), R9.2
unnamed: R4.1, U5.24 (RB3)
unnamed: R5.1, U5.25 (RB4)
unnamed: R6.1, U5.1 (~MCLR)
unnamed: R9.1, U5.23 (RB2)

Notes on the sheet:
Debugging LEDs Vs = 5V
RED
Normal Header
BLUE
CLEAR
Harwin Connector

Parts:
C7, C12: 0.1n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8: 1n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C15, C17: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C16: 2.2n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: CUS08F30H3FCT-ND; D_SOD-323_HandSoldering
JP1: TRANS_JUMP; PinHeader_1x02_P2.54mm_Vertical
JP2: AMP_JUMP; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R11: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3: 1.2k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R12, R13: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TP1: FILTER; PinHeader_1x01_P2.54mm_Vertical
TP2: PEAK_OUT; PinHeader_1x01_P2.54mm_Vertical
U1, U4: LTC6269; MSOP-8_3x3mm_P0.65mm
U13: Broadcom_SiPM_1; BROADCOM_SiPM

Connections:
+4.7V: C15.1, C17.1, U1.8 (V+), U4.8 (V+); also elsewhere on the board
+36V: U13.2 (A+); also elsewhere on the board
/AMP_OUT_1: JP2.2, U4.3 (+INA); also elsewhere on the board
/DET_ADC_1: TP2.1, U4.6 (-INB), U4.7 (OUTB); also elsewhere on the board
/Detector Circuit 1/Filter_IN: C8.2, JP1.2
/Detector Circuit 1/SIPM_OUT_1: C7.2, R1.2, U1.2 (-INA), U13.1 (C-)
GND: C12.1, C15.2, C16.2, C17.2, R2.2, R11.2, R13.2, U1.3 (+INA), U1.4 (V-), U4.4 (V-); also elsewhere on the board
unnamed: C7.1, JP1.1, R1.1, U1.1 (OUTA)
unnamed: C8.1, R2.1, R3.2
unnamed: C12.2, R3.1, TP1.1, U1.5 (+INB)
unnamed: C16.1, D1.1 (K), R13.1, U4.2 (-INA), U4.5 (+INB)
unnamed: D1.2 (A), U4.1 (OUTA)
unnamed: JP2.1, R12.1, U1.7 (OUTB)
unnamed: R11.1, R12.2, U1.6 (-INB)

Notes on the sheet:
Tdelay = RC
2.2ms peak detector
Filter frequency cutoff equation: 1/(2*pi*R*C)
Op-amp removes diode drop for peak detector
Voltage follower Ensures that measurments on ADC_OUT do not affect value
Amplifier
Transimpedance Amplifier: Gain = 150, output peak approx. 1V Low-pass cutoff = 1Mhz
Band-pass filter High-pass cutoff: 200kHz Low pass cut-off: 1Mhz Est. voltage drop: 300mV

Parts:
C18, C20: 0.1n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C19: 1n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C21, C23: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C22: 2.2n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: CUS08F30H3FCT-ND; D_SOD-323_HandSoldering
JP3: TRANS_JUMP; PinHeader_1x02_P2.54mm_Vertical
JP4: AMP_JUMP; PinHeader_1x02_P2.54mm_Vertical
R14, R15, R17: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R16: 1.2k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R18, R19: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TP3: FILTER; PinHeader_1x01_P2.54mm_Vertical
TP4: PEAK_OUT; PinHeader_1x01_P2.54mm_Vertical
U6, U7: LTC6269; MSOP-8_3x3mm_P0.65mm
U14: Broadcom_SiPM_2; BROADCOM_SiPM

Connections:
+4.7V: C21.1, C23.1, U6.8 (V+), U7.8 (V+); also elsewhere on the board
+36V: U14.2 (A+); also elsewhere on the board
/AMP_OUT_2: JP4.2, U7.3 (+INA); also elsewhere on the board
/DET_ADC_2: TP4.1, U7.6 (-INB), U7.7 (OUTB); also elsewhere on the board
/Detector Circuit 2/Filter_IN: C19.2, JP3.2
/Detector Circuit 2/SIPM_OUT_2: C18.2, R14.2, U6.2 (-INA), U14.1 (C-)
GND: C20.1, C21.2, C22.2, C23.2, R15.2, R17.2, R19.2, U6.3 (+INA), U6.4 (V-), U7.4 (V-); also elsewhere on the board
unnamed: C18.1, JP3.1, R14.1, U6.1 (OUTA)
unnamed: C19.1, R15.1, R16.2
unnamed: C20.2, R16.1, TP3.1, U6.5 (+INB)
unnamed: C22.1, D2.1 (K), R19.1, U7.2 (-INA), U7.5 (+INB)
unnamed: D2.2 (A), U7.1 (OUTA)
unnamed: JP4.1, R18.1, U6.7 (OUTB)
unnamed: R17.1, R18.2, U6.6 (-INB)

Notes on the sheet:
Filter frequency cutoff equation: 1/(2*pi*R*C)
Amplifier
Tdelay = RC
Voltage follower Ensures that measurments on ADC_OUT do not affect value
Transimpedance Amplifier: Gain = 150, output peak approx. 1V Low-pass cutoff = 1Mhz
2.2ms peak detector
Op-amp removes diode drop for peak detector
Band-pass filter High-pass cutoff: 200kHz Low pass cut-off: 1Mhz Est. voltage drop: 300mV

Parts:
C24, C26: 0.1n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C25: 1n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C27, C29: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C28: 2.2n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D6: CUS08F30H3FCT-ND; D_SOD-323_HandSoldering
JP5: TRANS_JUMP; PinHeader_1x02_P2.54mm_Vertical
JP6: AMP_JUMP; PinHeader_1x02_P2.54mm_Vertical
R20, R21, R23: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R22: 1.2k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R24, R25: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TP5: FILTER; PinHeader_1x01_P2.54mm_Vertical
TP6: PEAK_OUT; PinHeader_1x01_P2.54mm_Vertical
U8, U9: LTC6269; MSOP-8_3x3mm_P0.65mm
U15: Broadcom_SiPM_3; BROADCOM_SiPM

Connections:
+4.7V: C27.1, C29.1, U8.8 (V+), U9.8 (V+); also elsewhere on the board
+36V: U15.2 (A+); also elsewhere on the board
/AMP_OUT_3: JP6.2, U9.3 (+INA); also elsewhere on the board
/DET_ADC_3: TP6.1, U9.6 (-INB), U9.7 (OUTB); also elsewhere on the board
/Detector Circuit 3/Filter_IN: C25.2, JP5.2
/Detector Circuit 3/SIPM_OUT_3: C24.2, R20.2, U8.2 (-INA), U15.1 (C-)
GND: C26.1, C27.2, C28.2, C29.2, R21.2, R23.2, R25.2, U8.3 (+INA), U8.4 (V-), U9.4 (V-); also elsewhere on the board
unnamed: C24.1, JP5.1, R20.1, U8.1 (OUTA)
unnamed: C25.1, R21.1, R22.2
unnamed: C26.2, R22.1, TP5.1, U8.5 (+INB)
unnamed: C28.1, D6.1 (K), R25.1, U9.2 (-INA), U9.5 (+INB)
unnamed: D6.2 (A), U9.1 (OUTA)
unnamed: JP6.1, R24.1, U8.7 (OUTB)
unnamed: R23.1, R24.2, U8.6 (-INB)

Notes on the sheet:
Amplifier
Filter frequency cutoff equation: 1/(2*pi*R*C)
Voltage follower Ensures that measurments on ADC_OUT do not affect value
Op-amp removes diode drop for peak detector
2.2ms peak detector
Tdelay = RC
Transimpedance Amplifier: Gain = 150, output peak approx. 1V Low-pass cutoff = 1Mhz
Band-pass filter High-pass cutoff: 200kHz Low pass cut-off: 1Mhz Est. voltage drop: 300mV

Parts:
C30, C31: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R26, R27, R28: 5.1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R32, R34, R36: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R33, R35, R37: 15k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TP7, TP8, TP9: COMP_BIAS; PinHeader_1x01_P2.54mm_Vertical
TP10, TP11, TP12: INTERRUPT; PinHeader_1x01_P2.54mm_Vertical
U11, U12: AS393P-E1; DIP-8_W7.62mm

Connections:
+5V: C30.1, C31.1, R26.1, R27.1, R28.1, R32.1, R34.1, R36.1, U11.8 (VCC), U12.8 (VCC); also elsewhere on the board
/AMP_OUT_1: U11.2 (1-); also elsewhere on the board
/AMP_OUT_2: U11.6 (2-); also elsewhere on the board
/AMP_OUT_3: U12.2 (1-); also elsewhere on the board
/Comparitor Circuits/INTERRUPT_1: R26.2, TP10.1, U11.1 (O1); also elsewhere on the board
/Comparitor Circuits/INTERRUPT_2: R28.2, TP11.1, U11.7 (O2); also elsewhere on the board
/Comparitor Circuits/INTERRUPT_3: R27.2, TP12.1, U12.1 (O1); also elsewhere on the board
GND: C30.2, C31.2, R33.2, R35.2, R37.2, U11.4 (GND), U12.4 (GND), U12.5 (2+), U12.6 (2-); also elsewhere on the board
unnamed: R32.2, R33.1, TP7.1, U11.3 (1+)
unnamed: R34.2, R35.1, TP8.1, U11.5 (2+)
unnamed: R36.2, R37.1, TP9.1, U12.3 (1+)

Notes on the sheet:
Comparator triggers interrrupt, which informs PIC to measure analog signal

Board: 4 copper layers, 80.0 x 86.0 mm, 111 parts (6 on the bottom side), 65 nets.

## KiCad design proto_board/detector_circuit_LTC6269/detector_circuit_LTC6269.kicad_pcb

File proto_board/README.md:

***************************************Protoboard**************************************

Two parts:

	detector_support:
		* All the supporting infastrucutre, power suppies, logging
	detector_circuit
		* Converts current spike from SiPM to voltage for logging.
			* detector_circuit_LTC6269.sch - Version with LTC6269 op amp. 
			  this amp has been tested and works, but is expensive and consumes 
                          a lot of current, not ideal for flight.
		* detector_circuit_LTC6254 - Version with LTC6264 op amp, previously untested
                  but cheaper and has a significantly lower quiescent current.
		* detector_circuit_alt_LTC6254 - Different version of transimpedance amplifier with 
		  filtering built in. Experimental, but it would be really cool and worth a try. 

Each of the detector circuits connect to the support board with the listed connectors:
* J9 - SIPM_CONN
* J2 - DET_CONN_PWR
* J11 

***********************************Project Overview***********************************

Measuring the radiation detection properties of BNNTs and Metal Oxides.

Radiaiton detection
Scintillator - Lights up when exposed to ionizing radiation
SiPM - Silicon photomultiplier, sensor that counts the number of photons it sees.

Scintillator generates light, SiPM generates a current pulse proportional 
to the magnitude of radiation.

In order to detect and log that current pulse on an MCU we need to
1. Convert the current signal to voltage 
2. Amplify the voltage pulse to increase difference between singal and noise
and make it easier to detect and losses negligible.
3. Extend the length of the signal so the MCU has time to made an ADC conversion.

Detector Circuit Topology:

1. Transimpdance amplifier converts current signal to voltage, amplifies it in a way
to reduce the signal to noise ratio. The main purpose of this board is to fine-tune the 
resistor and capacitor values to optimize the gain on this amplifier.
2. Filter stage to eliminaty high and low frequency noise
3. Second stage amplfication
4. Peak detector to extend signal
5. Voltage follower to ensure signal sampling does not interfere with the peak detector circuit.

Data logging:

After the second stage amplificaiton, the signal line is sent to both the peak detector and a comparator.
The comparator compares the signal to a set baseline voltage value, and if the signal exceeds this amount,
it generates an interrupt. This interrupt is used to tell the MCU when to take an ADC sample from the 
peak detector line. 

Voltage supply:

Because the detector circuit is sensative anlaog circuitry, it runs off a seperate 4.7V line 
from an LDO. The LDO cleans the 5V line to ensure low-noise, as well as seperates the detector
circuit supplies from any noise generated by the switching supplies.

The SiPM requires 36V to operate. This is achieved with a voltage booster paried with an LDO to 
make sure the supply voltage is clean. 

The detector_support circuit is configured to support both a test connection (5V and 12V from the 
bench top supply) as well as battery connections for use in lab testing.

Board: 4 copper layers, 69.2 x 53.2 mm, 39 parts (0 on the bottom side), 15 nets.

Parts:
C17, C18, C19: DNP; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C27, C37: 2.2n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C31, C33: 1n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C32: 10n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C35, C39: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C36: 470p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2, D6: CUS08F30H3FCT-ND; D_SOD-323_HandSoldering
J1: DET_CONN_PWR; PinHeader_1x02_P2.54mm_Vertical
J2: SIPM_CONN; PinHeader_1x02_P2.54mm_Vertical
J3: DET_CONN; PinHeader_1x04_P2.54mm_Vertical
JP1: AMP_JUMP; PinHeader_1x02_P2.54mm_Vertical
JP5: TRANS_JUMP; PinHeader_1x02_P2.54mm_Vertical
R1: 1; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R16, R17, R31, R32, R33, R34, R35, R36, R39: DNP; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R24, R26: 100; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R25, R40: 150; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R27: 330; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R30, R42: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TP1: PEAK_OUT; PinHeader_1x01_P2.54mm_Vertical
TP15: FILTER; PinHeader_1x01_P2.54mm_Vertical
U12, U13: LTC6269; MSOP-8_3x3mm_P0.65mm

Connections:
+4.7V: C35.1, C39.1, J1.2, U12.8, U13.8
/AMP_OUT: C27.1, J3.2, JP1.2, R42.1, U13.3
/DET_ADC: J3.3, TP1.1, U13.6, U13.7
/Filter_IN: C17.2, C32.2, JP5.2
/SIPM_OUT: J2.1, J3.4, R1.2
GND: C18.1, C19.2, C27.2, C33.1, C35.2, C37.2, C39.2, J1.1, J3.1, R24.2, R26.2, R30.2, R32.2, R34.1, R39.2, R42.2, U12.3, U12.4, U13.4
unnamed: C17.1, R32.1, R33.2
unnamed: C18.2, C33.2, R25.1, R33.1, TP15.1, U12.5
unnamed: C19.1, C37.1, D2.1, D6.1, R30.1, R39.1, U13.2, U13.5
unnamed: C31.1, JP5.1, R16.1, R17.1, R31.1, R40.1, U12.1
unnamed: C31.2, R1.1, R16.2, R17.2, R31.2, R40.2, U12.2
unnamed: C32.1, R24.1, R25.2
unnamed: C36.1, JP1.1, R27.1, R35.1, R36.1, U12.7
unnamed: C36.2, R26.1, R27.2, R34.2, R35.2, R36.2, U12.6
unnamed: D2.2, D6.2, U13.1
