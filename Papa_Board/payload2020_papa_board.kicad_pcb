# Repository waterloo-rocketry/Payload-2020

File README.md:

# Waterloo Rocketry Payload 2020/2021

Waterloo Rocketry's Payload hardware and software for the radiation materials analysis experiment
*BRANCH TO TRACK MODIFICATIONS MADE FOR FLIGHT*

## Contents

PCB Hardware and embedded software for:
* Papa board (power management, logging)
* Mama board (particle detection, noise filtering)
* Protoboard (Mama board prototype board)

Geant4 Monte Carlo simulations have been moved to Payload-Sims

Software for the in-flight controller (see [firmware readme](controller_firmware/README.md))

## Prerequisites

* KiCad
* Geant4
	* See [this link](http://geant4-userdoc.web.cern.ch/geant4-userdoc/UsersGuides/InstallationGuide/html/index.html) for more information on setting up the Geant4 environment
* STM32CubeIDE (see [firmware readme](controller_firmware/README.md))

## KiCad design Papa_Board/payload2020_papa_board.kicad_pcb

Parts:
H1, H2, H3, H4, H5, H6, H7, H8: MountingHole_Pad; MountingHole_3.5mm_Pad_Via
J2: Conn_02x06; connector_Harwin_M80-5000642
J3: Conn_02x06; PinHeader_1x05_P2.54mm_Vertical
J4, J12: Conn_01x05; PinHeader_2x03_P2.00mm_Vertical_MINISENSOR_Harwin_Spacing
J5, J6: M80-5000642; connector_Harwin_M80-5000642

Connections:
5V_MAMA: J5.1, J6.1; also elsewhere on the board
+5V: J4.2, J12.2; also elsewhere on the board
+37V: J5.2, J6.2; also elsewhere on the board
/CANH_PAYLOAD: J4.4, J5.4, J6.4, J12.4; also elsewhere on the board
/CANH_ROCKET: J2.4; also elsewhere on the board
/CANL_PAYLOAD: J4.5, J5.5, J6.5, J12.5; also elsewhere on the board
/CANL_ROCKET: J2.5; also elsewhere on the board
/ICSPCLK: J3.1; also elsewhere on the board
/ICSPDAT: J3.2; also elsewhere on the board
/~MCLR: J3.5; also elsewhere on the board
GND: H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, H7.1, H8.1, J2.3, J3.3, J4.3, J5.3, J6.3, J12.3; also elsewhere on the board

Notes on the sheet:
Mama_Board_2
Harwin connector
Grounded to cubesat
Normal header
Connector for programming
To Rocket CAN bus
Mama_Board_1
Logger Board
Minisensor

Parts:
C1: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: C; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 15uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C21, C28: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7: 100uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C17: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C18, C19, C27: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C22, C26: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C23: 47nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C24: 1.5nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C25: 10uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D1: 570mV 1A; D_SOD-123F
D2, D6: 40V 2A; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
F1: 500mA; Fuse_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1, J7, J9, J10: Conn_01x02_Female; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J11: GND TEST CONN; PinHeader_1x02_P2.54mm_Vertical
L1: 33uH; L_1210_3225Metric_Pad1.42x2.65mm_HandSolder
L2: 47uH; L_Wuerth_WE-PD-Typ-LS_Handsoldering
R3, R17, R18, R20: 0; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R11: 20mR; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R8: 86.6kR; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13: 18.7kR; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14: 470kR; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15: 16.2kR; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16: 10kR 0.25W; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R19: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R29: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R30: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1, TP3, TP6, TP8, TP10: TestPoint; PinHeader_1x01_P2.54mm_Vertical
U1, U2: INA180A4QDBVRQ1; SOT-23-5_HandSoldering
U3: AP1509; SOIC-8_3.9x4.9mm_P1.27mm
U4: FPF2125; SOT-23-5_HandSoldering
U6: TPS61175QPWPRQ1; HTSSOP-14-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask3x3.1mm_Thermal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
U9: AP2114H; SOT-223-3_TabPin2

Connections:
3V3_CURR_AMP: U2.1 (VO); also elsewhere on the board
5V_MAMA: C28.1, TP1.1, U4.5 (VOUT); also elsewhere on the board
+5V: C17.2, C21.2, C27.1, D6.1 (K), R20.1, TP6.1, U1.5 (VS), U2.5 (VS), U4.1 (VIN); also elsewhere on the board
+37V: C1.1, C25.1, C26.1, D1.1 (K), R14.1, R16.1, TP8.1; also elsewhere on the board
+BATT: C22.1, R3.1, R7.1, R17.1, R29.1, TP3.1, U1.4 (IN-)
/37V_EN: U6.4 (EN); also elsewhere on the board
BATT_CURR_AMP: U1.1 (VO); also elsewhere on the board
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.1, C17.1, C18.1, C19.1, C21.1, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, D2.2 (A), J10.1, J11.1, J11.2, R8.2, R15.2, R16.2, R19.2, R30.2, U1.2 (GND), U2.2 (GND), U3.4 (SD), U3.5 (GND), U3.6 (GND), U3.7 (GND), U3.8 (GND), U4.2 (GND), U6.6 (SYNC), U6.7 (AGND), U6.11 (NC), U6.12 (PGND), U6.13 (PGND), U6.14 (PGND), U6.15 (TGND), U9.1 (GND); also elsewhere on the board
MAMA_PWR_EN: U4.3 (ON); also elsewhere on the board
unnamed: C2.1, C6.1, C7.2, D6.2 (A), L2.2, U3.3 (FB)
unnamed: C4.1, C5.1, R3.2, U3.1 (Vin)
unnamed: C18.2, R20.2, U9.3 (VIN)
unnamed: C19.2, R18.1, U9.2 (VOUT)
unnamed: C23.1, U6.5 (SS)
unnamed: C24.1, R13.1
unnamed: D1.2 (A), L1.2, U6.1 (SW), U6.2 (SW)
unnamed: D2.1 (K), L2.1, U3.2 (Output)
unnamed: F1.1, J1.2
unnamed: F1.2, R7.2, U1.3 (IN+)
unnamed: J1.1, J7.2
unnamed: J7.1, J9.2
unnamed: J9.1, J10.2
unnamed: L1.1, R17.2, U6.3 (VIN)
unnamed: R8.1, U6.10 (FREQ)
unnamed: R11.2, R18.2, U2.3 (IN+)
unnamed: R13.2, U6.8 (COMP)
unnamed: R14.2, R15.1, U6.9 (FB)
unnamed: R19.1, U4.4 (ISET)
V_SENSE: R29.2, R30.1; also elsewhere on the board

Notes on the sheet:
Mama board 5V power switch
12V-16V
To mama board
12-16V
PMEG6010CEH
Max power = (37^2)/(9500) = 0.144 W
I min for the boost converter to operate in PWM mode is 3mA Choose 10k resistor, 5% tol: Worst-case (max) resistance = 10000ohm*(1 + 0.05) = 10500 ohms I_min = 37V/10500 ohms = 3.5mA -> above min load current for PWM operation
4 LiPO Cells in series
100V/V
66.25mR * I * 200v/v = 5.3V Imax = 400mA
Rset = 460/I_lim (current limit)
Battery Connectors
MAMA_PWR_EN set by MCU, HIGH = power to mama board, LOW = no power to mama board
Bias Voltage for SiPM
1A max i think
Voltage Sensing
Logic High
1.09-1.46V output
PDF version: https://drive.google.com/file/d/13pYM-p7NzZnNQYZXknj9P6BV4uZ4R9wv/view?usp=sharing
AP1509 is a buck converter. Iout: 2A Values are taken from datasheet.
BCL322515RT-330M-D
PDF version: https://drive.google.com/file/d/1ktwurgh3BjmDxpc3J00zTu8lIix18m34/view?usp=sharing
MCU, CAN, SDcard power supply
DNP capacitor
Worst-case (min) resistance = 10000 ohms * 0.95 = 9500 ohms
AP2114H is a 3.3V LDO Max Iout rating = 1A
VIH = 1.3V when Vin = 5.5V, so will turn on with 3V3 logic
Main Power Supplies
TPS61175 is a boost converter. Max Iout rating: 3A Values are taken from WEBENCH power designer https://webench.ti.com/appinfo/webench/scripts/SDP.cgi?ID=944A159EFA65DE89
Shottkey diode to protect line from other power sources
SD1206S040S2R0

Parts:
C3, C11, C29: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C9, C10: 27pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12, C13, C14, C15, C16: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D3: QBLP650-IW; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D4: 156120RS75000; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D5: 150120BS75000; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R2, R24: 10kR; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5, R9: 150R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 10kR; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R10: 100R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U5: MCP2515-I/P; SOIC-18W_7.5x11.6mm_P1.27mm
U7, U10: MCP2562-E/SN; SOIC-8_3.9x4.9mm_P1.27mm
U8: DSPIC33EP256GP502; SOIC-28W_7.5x17.9mm_P1.27mm
Y1: 12MHz; Crystal_HC49-4H_Vertical

Connections:
3V3_CURR_AMP: U8.3 (AN1/C2IN1+/RA1); also elsewhere on the board
+5V: C13.1, C15.1, U7.3 (VDD), U10.3 (VDD); also elsewhere on the board
/37V_EN: U8.4 (PGED3/VREF-/AN2/C2IN1-/RPI32/CTED2/RB0); also elsewhere on the board
/CANH_PAYLOAD: U10.7 (CANH); also elsewhere on the board
/CANH_ROCKET: U7.7 (CANH); also elsewhere on the board
/CANL_PAYLOAD: U10.6 (CANL); also elsewhere on the board
/CANL_ROCKET: U7.6 (CANL); also elsewhere on the board
/ICSPCLK: U8.6 (PGEC1/AN4/C1IN1+/RPI34/RB2); also elsewhere on the board
/ICSPDAT: U8.7 (PGED1/AN5/C1IN1-/RP35/RB3); also elsewhere on the board
/MCU and CAN controllers/CAN_INT: U5.12 (~INT), U8.21 (TDO/RP42/RB10)
/MCU and CAN controllers/CLKOUT: U5.8 (OSC1), U8.22 (TDI/RP43/RB11)
/MCU and CAN controllers/CS_1: R24.2, U5.16 (~CS), U8.15 (PGEC2/ASCL2/RP38/RB6)
/MCU and CAN controllers/CS_2: U8.14 (PGED2/ASDA2/RP37/RB5); also elsewhere on the board
/MCU and CAN controllers/MCP_RX: U5.2 (RXCAN), U7.4 (RXD)
/MCU and CAN controllers/MCP_TX: U5.1 (TXCAN), U7.1 (TXD)
/MCU and CAN controllers/MISO: U5.15 (SO), U8.17 (TCK/CVREF1O/ASCL1/SDO1/RP40/T4CK/RB8); also elsewhere on the board
/MCU and CAN controllers/MOSI: U5.14 (SI), U8.18 (TMS/ASDA1/SDI1/RP41/RB9); also elsewhere on the board
/MCU and CAN controllers/OSC1: C9.1, U8.9 (OSC1/CLKI/RA2), Y1.1
/MCU and CAN controllers/OSC2: C10.1, U8.10 (OSC2/CLKO/RA3), Y1.2
/MCU and CAN controllers/PIC_RX: U8.12 (CVREF2O/RP20/T1CK/RA4), U10.4 (RXD)
/MCU and CAN controllers/PIC_TX: U8.11 (RP36/RB4), U10.1 (TXD)
/MCU and CAN controllers/SCK: U5.13 (SCK), U8.16 (SCK1/RP39/INT0/RB7); also elsewhere on the board
/~MCLR: C3.1, R6.2, R10.2; also elsewhere on the board
BATT_CURR_AMP: U8.2 (AN0/OA2OUT/RA0); also elsewhere on the board
GND: C3.2, C8.2, C9.2, C10.2, C11.1, C12.2, C13.2, C14.2, C15.2, C16.2, C29.2, D3.1 (K), D4.1 (K), D5.1 (K), U5.9 (VSS), U7.2 (VSS), U7.8 (STBY), U8.8 (VSS), U8.19 (VSS), U8.27 (AVSS), U10.2 (VSS), U10.8 (STBY); also elsewhere on the board
MAMA_PWR_EN: U8.26 (RPI47/T5CK/RB15); also elsewhere on the board
unnamed: C8.1, U8.20 (VCAP)
unnamed: D3.2 (A), R9.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: R2.2, U5.17 (~RESET)
unnamed: R4.1, U8.24 (RPI45/CTPLS/RB13)
unnamed: R5.1, U8.23 (RPI44/RB12)
unnamed: R9.1, U8.25 (RPI46/T3CK/RB14)
unnamed: R10.1, U8.1 (~MCLR)
V_SENSE: U8.5 (PGEC3/VREF+/AN3/OA1OUT/RPI33/CTED1/RB1); also elsewhere on the board

Notes on the sheet:
Terminanting resistors will be on the CAN harness
RED
WHITE
To logger board
Not all pins support peripheral output. RP20 and RP35-43 are the pins that support peripheral ouptut.
BLUE
Mama board power is on when MAMA_PWR_EN is high.
Debugging LEDs Vs = 3.3V

Parts:
C20: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J8: 693072010801; microSD_Molex_WM6698CT-ND
R12, R21, R22, R23: 10kR; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
/MCU and CAN controllers/CS_2: J8.2 (DAT3/CD), R12.2; also elsewhere on the board
/MCU and CAN controllers/MISO: J8.7 (DAT0), R23.2; also elsewhere on the board
/MCU and CAN controllers/MOSI: J8.3 (CMD), R21.2; also elsewhere on the board
/MCU and CAN controllers/SCK: J8.5 (CLK), R22.2; also elsewhere on the board
GND: C20.2, J8.6 (VSS), J8.9 (SHIELD); also elsewhere on the board

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
Board: 4 copper layers, 82.0 x 82.0 mm, 100 parts (45 on the bottom side), 59 nets.

Other parts of the board:
GND: PinHeader_1x04_P2.54mm_Vertical

Their connections:
GND: GND.1, GND.2, GND.3, GND.4; also elsewhere on the board

## KiCad design mama_board/mama_board.kicad_pcb

Parts:
J4: M80-5000642; connector_Harwin_M80-5000642

Connections:
+5.4V: J4.1; also elsewhere on the board
+37V: J4.2; also elsewhere on the board
GND: J4.3; also elsewhere on the board

Notes on the sheet:
To make ERC happy
Papa Board

Parts:
C1, C2, C5: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4: 10n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6: 0.5u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F1, F3: 400ma; Fuse_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J7: TEST_CONN; PinHeader_1x03_P2.54mm_Vertical
R7: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R8: 3.5k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U2: LD3985M47R_SOT23; SOT-23-5
U3: LT3014IS5#TRMPBF; TSOT-23-5_HandSoldering

Connections:
+4.7V: C5.1, U2.5 (VOUT); also elsewhere on the board
+5.4V: C2.1, U2.1 (VIN), U2.3 (INH); also elsewhere on the board
+5V: F3.1, U3.3 (~SHDN); also elsewhere on the board
+36V: C6.1, R7.1, U3.5 (OUT); also elsewhere on the board
+37V: C1.1, F1.1, U3.1 (IN); also elsewhere on the board
GND: C1.2, C2.2, C4.2, C5.2, C6.2, J7.1, R8.2, U2.2 (GND), U3.2 (GND); also elsewhere on the board
unnamed: C4.1, U2.4 (BYP)
unnamed: F1.2, J7.2
unnamed: F3.2, J7.3
unnamed: R7.2, R8.1, U3.4 (ADJ)

Notes on the sheet:
LDOs for noise reduction
