# Repository waterloo-rocketry/Payload-2020 (continued)

## KiCad design proto_board/detector_circuit.kicad_pcb

Board: 4 copper layers, 94.0 x 99.1 mm, 85 parts (0 on the bottom side), 56 nets.

Parts:
C1, C2, C5, C21, C23, C24: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C40: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4, C25: 10n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6: 0.5u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C7: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8: 47n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C9, C10: 26pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C11, C13, C14: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C12: 1.5n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C15, C16: 10u; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C20: 4.7uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C22: 4.7u; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C26: 56u; C_1210_3225Metric_Pad1.42x2.65mm_HandSolder
D1: 570mV 1a; D_SOD-123F
D3: 156120RS75000; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D4: 150120BS75000; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D5: QBLP650-IW; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D7: D; D_SMA_Handsoldering
F1, F3, F4, F5, F6: 400ma; Fuse_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Programming Header; PinHeader_1x05_P2.54mm_Vertical
J2: DET_CONN_PWR; PinHeader_1x02_P2.54mm_Vertical
J3: BATT_1; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J4: BATT_2; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J5: BATT_3; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J6: BATT_4; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J7: TEST_CONN; PinHeader_1x03_P2.54mm_Vertical
J8: 693072010801; microSD_Molex_WM6698CT-ND
J9: SIPM_CONN; PinHeader_1x02_P2.54mm_Vertical
J10: Conn_01x06_Female; connector_Harwin_M80-5000642
J11: DET_CONN; PinHeader_1x04_P2.54mm_Vertical
JP2: TEST/BATT; PinHeader_1x03_P2.54mm_Vertical
L1: 33u; L_1210_3225Metric
L2: 15u; 732-3880-1-ND
Q1: BSS138; SOT-23
R1, R3, R10, R12: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2: 20; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4, R5, R9, R41: 330; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6: 100; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R7, R28: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R8: 3.5k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R11: 85.4k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R13: 18.2k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R14: 470k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R15: 16.2k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R18, R19, R20: 34k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R21, R22, R23: 66k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R29: 15k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R37, R38: DNP; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
TP17: COMP_BIAS; PinHeader_1x01_P2.54mm_Vertical
U1: LM22678TJ-5.0_NOPB; TO-263-7_TabPin4
U2: LD3985M47R_SOT23; SOT-23-5
U3: LT3014IS5#TRMPBF; TSOT-23-5_HandSoldering
U4: AP2114H-3.3TRG1; SOT-223
U5: PIC18LF26K83; SOIC-28W_7.5x18.7mm_P1.27mm
U6: TPS61175QPWPRQ1; TPS61175_Q1_Footprint
U10: MCP2562-E/SN; SOIC-8_3.9x4.9mm_P1.27mm
U14: LT1711xMS8; MSOP-8_3x3mm_P0.65mm
Y1: 12MHz; Crystal_HC49-4H_Vertical

Connections:
+3V3: C20.1, C23.1, J8.4, Q1.1, R3.1, R12.1, U4.2, U4.4
+4.7V: C5.1, J2.2, U2.5
+5V: C2.1, C11.2, C13.1, C14.1, C21.2, C26.1, C40.1, F3.1, J1.2, L2.2, R1.1, R2.1, R10.1, R28.1, R37.1, U2.1, U2.3, U3.3, U4.3, U5.20, U10.3, U10.5, U14.1, U14.5
+12V: F1.1, JP2.3
+36V: C6.1, J9.2, R7.1, U3.5
+37V: C1.1, C15.1, C16.1, D1.1, R14.1, U3.1
+BATT: C22.1, C24.1, J3.2, JP2.1, U1.2
/AMP_OUT: J11.2, U14.2
/DET_ADC: J11.3, U5.17
/INTERUPT_OUT: U5.16, U14.8
/Microcontroller [DO NOT PLACE]/CANH: J10.4, U10.7
/Microcontroller [DO NOT PLACE]/CANL: J10.5, U10.6
/Microcontroller [DO NOT PLACE]/CS: R18.2, U5.7
/Microcontroller [DO NOT PLACE]/ICSPCLK: J1.5, U5.27
/Microcontroller [DO NOT PLACE]/ICSPDAT: J1.4, U5.28
/Microcontroller [DO NOT PLACE]/MCLR: C3.1, J1.1, R6.2, R10.2
/Microcontroller [DO NOT PLACE]/MISO: Q1.2, R1.2, R19.2, U5.13, U5.15
/Microcontroller [DO NOT PLACE]/OSC1: C9.1, U5.9, Y1.1
/Microcontroller [DO NOT PLACE]/OSC2: C10.1, U5.10, Y1.2
/Microcontroller [DO NOT PLACE]/PIC_RX: U5.12, U10.4
/Microcontroller [DO NOT PLACE]/PIC_TX: U5.11, U10.1
/Microcontroller [DO NOT PLACE]/SCK: R20.2, U5.14
/SIPM_OUT: J9.1, J11.4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.2, C13.2, C14.2, C15.2, C16.2, C20.2, C21.1, C22.2, C23.2, C24.2, C26.2, C40.2, D3.1, D4.1, D5.1, D7.2, J1.3, J2.1, J6.1, J7.1, J8.6, J8.9, J10.3, J11.1, R8.2, R11.2, R15.2, R21.2, R22.2, R23.2, R29.2, R38.2, R41.2, U1.4, U2.2, U3.2, U4.1, U5.8, U5.19, U6.6, U6.7, U6.12, U6.13, U6.14, U6.15, U10.2, U10.8, U14.4, U14.6
unnamed: C4.1, U2.4
unnamed: C7.1, JP2.2, L1.2, U6.3, U6.4
unnamed: C8.1, U6.5
unnamed: C12.1, R13.1
unnamed: C25.1, D7.1, L2.1, U1.1
unnamed: C25.2, U1.3
unnamed: D1.2, L1.1, U6.1, U6.2
unnamed: D3.2, R4.2
unnamed: D4.2, R5.2
unnamed: D5.2, R9.2
unnamed: F1.2, J7.2
unnamed: F3.2, J7.3
unnamed: F4.1, J3.1
unnamed: F4.2, J4.2
unnamed: F5.1, J4.1
unnamed: F5.2, J5.2
unnamed: F6.1, J5.1
unnamed: F6.2, J6.2
unnamed: J8.2, R3.2, R18.1, R22.1
unnamed: J8.3, R19.1, R23.1
unnamed: J8.5, R20.1, R21.1
unnamed: J8.7, Q1.3, R12.2
unnamed: R2.2, R41.1, U1.6
unnamed: R4.1, U5.24
unnamed: R5.1, U5.25
unnamed: R6.1, U5.1
unnamed: R7.2, R8.1, U3.4
unnamed: R9.1, U5.23
unnamed: R11.1, U6.10
unnamed: R13.2, U6.8
unnamed: R14.2, R15.1, U6.9
unnamed: R28.2, R29.1, R37.2, R38.1, TP17.1, U14.3

## KiCad design mama_board/payload2020_mama_board.kicad_pcb

Board: 2 copper layers, 95.0 x 82.0 mm, 101 parts (26 on the bottom side), 85 nets, no tracks yet.

Parts:
A1, A2: Arduino_Nano_v3.x; Arduino_Nano
C1, C2, C11, C12: 22pF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C3, C5, C6, C13: 10uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C4, C16, C17, C18: 100nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C7: 3.3nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C8, C9: 22uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C10: 47uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1, D5, D6: LED; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: MBRS130T3; D_SMB_Handsoldering
J1: Conn_01x05; connector_Harwin_M80-5000642_vertical
J2, J3, J7, J8: Conn_01x02; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J4, J6: Conn_01x06; connector_Harwin_M80-5000642
J5: Conn_01x08; connector_Harwin_M80-5000842
J9, J10: Micro_SD_Card; microSD_HC_Molex_104031-0811
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP14, JP15, JP16, JP17, JP18, JP19, JP20, JP21, JP22: Jumper; PinHeader_1x02_P2.54mm_Vertical
L1: 2.2uH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
L2: 33uH; CR54NP-330LC
Q1, Q4, Q5: Q_PMOS_GSD; SOT-23_Handsoldering
R1, R8, R9: 120; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4, R5, R10, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R31, R32, R33: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R11: 100k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R25, R28: 4.7k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
SW1, SW2: SW_Push; SW_PUSH_6mm
U1, U5: MCP2515-xSO; SOIC-18W_7.5x11.6mm_P1.27mm
U2: LD1117S33TR_SOT223; SOT-223-3_TabPin2
U3, U13: CD74HC4050; SOIC-16_3.9x9.9mm_P1.27mm
U4, U8: MCP2562-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
U6: TPS62143; VQFN-16-1EP_3x3mm_P0.5mm_EP1.68x1.68mm_ThermalVias
U7: LT1109A; SOIC-8_3.9x4.9mm_P1.27mm
U9: TCA9517; VSSOP-8_3.0x3.0mm_P0.65mm
U10: MS5607-02BA; LGA-8_3x5mm_P1.25mm
U11, U12: SM74611; TO-263-3_TabPin4
Y1, Y2: 16MHz; Crystal_HC49-4H_Vertical

Connections:
+3V3: C5.1, C17.2, C18.2, JP13.1, JP14.1, R31.1, R32.1, U2.2, U9.8, U10.1, U10.2
+5V: C4.1, C16.1, J6.4, JP7.2, JP11.1, JP12.1, JP20.1, R4.1, R5.1, R8.1, R10.1, R12.1, R13.1, R15.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, U2.3, U9.1, U9.5
/CAN HW/CANH: J1.4, U4.7, U8.7
/CAN HW/CANL: J1.5, U4.6, U8.6
/CAN HW/CAN_5v: C3.2, JP18.2, U1.18, U4.3, U4.5
/LED2: A2.19, R1.1, R9.1
/MISO1: J9.7, JP5.1, U1.15
/MISO2: J5.3, J10.7, JP10.1, U5.15
/MOSI1: JP4.1, U1.14, U3.5
/MOSI2: J5.2, JP9.1, U5.14, U13.5
/PG: A1.6, A2.6, R11.2, U6.4
/PWR_EN1: A1.5, Q1.1, R14.2
/PWR_EN2: A2.5, Q5.1, R33.2
/SCK1: JP6.1, U1.13, U3.3
/SCK2: J5.4, JP15.1, U5.13, U13.3
/SS1: A1.25, R20.2, U3.7
/SS2: A2.12, R21.2, U13.7
/SS3: A1.13, R22.2, U1.16
/SS4: A2.13, J5.1, R23.2
/SS5: A2.9, R24.2, U5.16
/Sheet5E8DAA69/SCL: J5.8, JP3.1, JP17.1, R4.2, U9.2
/Sheet5E8DAA69/SDA: J5.7, JP8.2, JP16.2, R5.2, U9.3
/Valve Controller/VALVE+: J6.5, J6.6, Q4.3
/battery_management/VIN: C6.1, U6.10, U6.11, U6.12, U6.13, U11.2, U11.4, U12.2, U12.4
/battery_management/VOUT: C8.1, JP2.1, L1.2, Q1.2, Q5.2, R11.1, R14.1, R33.1, U6.14
/sheet5E2B166E/CAN_5v: C13.2, JP19.2, U5.18, U8.3, U8.5
/~CAN_INT_1: A1.7, R10.2, U1.12
/~CAN_INT_2: A2.7, R17.2, U5.12
/~CAN_RESET_1: A1.8, R12.2, U1.17
/~CAN_RESET_2: A2.8, R18.2, U5.17
/~VALVE_EN: A2.26, Q4.1, R16.2
/~VALVE_SHUTDOWN: A2.25, R15.2, U7.7
GND: A1.4, A1.29, A2.4, A2.29, C1.2, C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C16.2, C17.1, C18.1, D1.1, D5.1, D6.1, J1.3, J3.1, J4.5, J4.6, J5.5, J6.1, J6.2, J6.3, J8.1, J9.6, J9.9, J10.6, J10.9, R25.2, R28.2, SW1.1, SW2.1, U1.9, U2.1, U3.8, U3.9, U3.11, U3.14, U4.2, U5.9, U6.5, U6.6, U6.7, U6.8, U6.15, U6.16, U6.17, U7.4, U7.5, U8.2, U9.4, U10.3, U10.4, U10.5, U13.8, U13.9, U13.11, U13.14
unnamed: A1.10, R13.2, SW1.2
unnamed: A1.14, JP4.2
unnamed: A1.15, JP5.2
unnamed: A1.16, JP6.2
unnamed: A1.22, J4.3, J4.4
unnamed: A1.23, JP8.1
unnamed: A1.24, JP3.2
unnamed: A2.10, R19.2, SW2.2
unnamed: A2.14, JP9.2
unnamed: A2.15, JP10.2
unnamed: A2.16, JP15.2
unnamed: A2.23, JP16.1
unnamed: A2.24, JP17.2
unnamed: C1.1, U1.7, Y1.1
unnamed: C2.1, U1.8, Y1.2
unnamed: C7.1, U6.9
unnamed: C9.1, JP20.2, L2.1, U7.1
unnamed: C10.1, D4.1, JP21.1, U7.8
unnamed: C11.1, U5.7, Y2.1
unnamed: C12.1, U5.8, Y2.2
unnamed: D1.2, R1.2
unnamed: D4.2, L2.2, U7.3
unnamed: D5.2, R8.2
unnamed: D6.2, R9.2
unnamed: J2.1, J3.2
unnamed: J2.2, JP1.1
unnamed: J4.1, J4.2, JP12.2
unnamed: J5.6, JP11.2
unnamed: J7.1, J8.2
unnamed: J7.2, JP22.1
unnamed: J9.2, U3.6
unnamed: J9.3, U3.4
unnamed: J9.4, JP13.2, U3.1
unnamed: J9.5, U3.2
unnamed: J10.2, U13.6
unnamed: J10.3, U13.4
unnamed: J10.4, JP14.2, U13.1
unnamed: J10.5, U13.2
unnamed: JP1.2, U11.1, U11.3
unnamed: JP7.1, Q1.3, Q5.3
unnamed: JP21.2, Q4.2, R16.1
unnamed: JP22.2, U12.1, U12.3
unnamed: L1.1, U6.1, U6.2, U6.3
unnamed: R25.1, U4.8
unnamed: R28.1, U8.8
unnamed: R31.2, U9.6, U10.7
unnamed: R32.2, U9.7, U10.8
unnamed: U1.1, U4.1
unnamed: U1.2, U4.4
unnamed: U5.1, U8.1
unnamed: U5.2, U8.4
SLEEP_5V: A1.27, A2.27, JP2.2, JP18.1, JP19.1

File payload2020_bom.xlsx:

| Ref numbers | Description | Part number | Number of Units | Cost Per Unit | Digikey Link | Total Cost
Base Board
 | C1, C2 | 22pF Capacitor | 311-1062-1-ND | 2 | 0.14000000000000001 | https://www.digikey.ca/product-detail/en/yageo/CC0603JRNPO9B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
 | C16, C17, C18 | 0.1uF Capacitor | 1276-1258-1-ND | 3 | 0.14000000000000001 | https://www.digikey.ca/product-detail/en/samsung-electro-mec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
 | C4, C5 | 560pF Capacitor | 311-1079-2-ND | 2 | 0.15 | https://www.digikey.ca/en/products/detail/yageo/CC0603KRX7R9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
 | C6, C3, C13 | 10uF Capacitor | 490-14372-2-ND | 3 | 0.31 | https://www.digikey.ca/en/products/detail/murata-electronics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
 | C7 | 3.3nF Capacitor | 311-1082-2-ND | 1 | 0.15 | https://www.digikey.ca/en/products/detail/yageo/CC0603KRX7R9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
 | C8, C9 | 22uF Capacitor | 490-7611-2-ND | 2 | 0.4 | https://www.digikey.ca/en/products/detail/murata-electronics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
 | C10 | 47uF Capacitor | 490-13244-2-ND | 1 | 0.76 | https://www.digikey.ca/en/products/detail/murata-electronics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
 | D1, D5, D6 | Orange Debug LED | 1080-1586-2-ND | 3 | 0.6 | https://www.digikey.ca/en/products/detail/everlight-electron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
 | JP1-15 | 2 pin jumper male | 952-2262-ND | 15 | 0.17 | https://www.digikey.ca/en/products/detail/harwin-inc/M20-999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
 |  | 2 pin jumper female | S9337-ND | 15 | 0.15 | https://www.digikey.ca/en/products/detail/sullins-connector-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
 | J1, J4, J6 | Harwin 2x3 connector male | 952-1000-5-ND | 3 | 12.35 | https://www.digikey.ca/product-detail/en/harwin-inc/M80-5000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
 |  | Harwin 2x3 connector female | 952-3779-ND | 3 | 8.34 | https://www.digikey.ca/en/products/detail/harwin-inc/M80-418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
 | J5 | Harwin 2x4 connector male | 952-2341-ND | 1 | 17.940000000000001 | https://www.digikey.ca/product-detail/en/harwin-inc/M80-5100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
 |  | Harwin 2x4 connector female | 952-3732-ND | 1 | 6.95 | https://www.digikey.ca/en/products/detail/harwin-inc/M80-414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
 | L1 | 2.2uH inductor | 283-MCL2012V1-2R2-RCT-ND | 1 | 0.34 | https://www.digikey.ca/en/products/detail/eaton-electronics-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
 | L2 | 33uH inductor | 308-1535-2-ND | 1 | 1.36 | https://www.digikey.ca/en/products/detail/sumida-america-com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
 | A1, A2 | Arduino Nano |  | 2
 | Q1, Q5 | Power PMOS | 785-1010-1-ND | 3 | 0.56999999999999995 | https://www.digikey.ca/product-detail/en/alpha-omega-semicon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
 | R3-5, R7, R10, R12-R24, R31-R33 | 10k pullup resistor | 311-10KGRCT-ND | 21 | 0.15 | https://www.digikey.ca/product-detail/en/yageo/RC0603JR-0710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
 | R11 | 100k Pullup | RR08P100KDCT-ND | 1 | 0.15 | https://www.digikey.ca/product-detail/en/susumu/RR0816P-104-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
 | R25, R28 | 4.7k Resistor | 311-4.70KHRCT-ND | 2 | 0.15 | https://www.digikey.ca/product-detail/en/yageo/RC0603FR-074K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
 | R26, R27, R29, R30 | 100 ohm resistor | 311-100HRCT-ND | 4 | 0.15 | https://www.digikey.ca/product-detail/en/yageo/RC0603FR-0710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
 | R1, R8, R9 | 120 ohm resistor | A129677CT-ND | 3 | 0.15 | https://www.digikey.ca/product-detail/en/te-connectivity-pas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
 | SW1, SW2 | Pushbutton Switch | 450-1650-ND | 2 | 0.15 | digikey.ca/product-detail/en/te-connectivity-alcoswitch-switches/1825910-6/450-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
 | U1, U5 | CAN Controller | MCP2515-E/SO-ND | 2 | 3.18 | https://www.digikey.ca/en/products/detail/microchip-technolo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
 | U4, U8 | CAN Transceiver | MCP2562-E/SN-ND | 2 | 1.38 | https://www.digikey.ca/en/products/detail/microchip-technolo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
 | U2, U3 | Adafruit SD Breakout
 | U6 | 5v Switching Regulator | 296-39448-2-ND | 1 | 3.18 | https://www.digikey.ca/en/products/detail/texas-instruments/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
 | U7 | 12v boost regulator | LT1109ACS8-12#PBF-ND | 1 | 8.6999999999999993 | https://www.digikey.ca/product-detail/en/linear-technology-a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
 | U9 | I2C level shifter | 296-35972-1-ND | 1 | 1.01 | https://www.digikey.com/product-detail/en/texas-instruments/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
 | U10 | Altimeter | 223-1198-1-ND | 1 | 3.78 | https://www.digikey.com/product-detail/en/te-connectivity-me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
 | Y1, Y2 | Oscillator |  | 2
 |  | SD Card Slot |  |  |  | https://www.digikey.ca/product-detail/en/molex/1040310811/WM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
 |  | 3.3v linear regulator |  |  |  | https://www.digikey.com/product-detail/en/stmicroelectronics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
 |  | Logic shifter |  |  |  | https://www.digikey.ca/product-detail/en/texas-instruments/C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
 | Q4 | NMOS power | 785-1460-1-ND | 1 | 0.6 | https://www.digikey.ca/product-detail/en/alpha-omega-semicon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

## KiCad design Payload2020_SIPM_board/Payload2020_SIPM_board.kicad_pcb

Board: 2 copper layers, 25.0 x 25.0 mm, 14 parts (1 on the bottom side), 8 nets.

Parts:
C12: 20nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2: D_Schottky; D_SMA_Handsoldering
J1: Conn_01x03; FanPinHeader_1x03_P2.54mm_Vertical
R5: 49.9; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R7: 249; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R8, R9: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R10, R11: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R12: 24.9k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U2: Broadcom_sipm; Broadcom_SiPM_Breakout
U3, U4: TLV2402-Q1; SOT-23-5_HandSoldering

Connections:
+5V: J1.1, U3.5, U4.5
GND: C12.2, J1.3, R5.2, R7.2, R9.2, R10.2, R12.2, U3.2, U4.2
unnamed: R8.2, R9.1, U3.1, U4.3
unnamed: R7.1, R8.1, U3.4
unnamed: C12.1, D2.1, J1.2, R11.1, R12.1
unnamed: D1.1, D2.2, U4.1
unnamed: D1.2, R10.1, R11.2, U4.4
unnamed: R5.1, U2.2, U3.3

## Code that names these connections

File papaboardcode.X/init.c:

#include "init.h"
#include "sd.h"
#include "can_syslog.h"
#include "dspic33epxxxgp50x_can.h"
#include "timing_util.h"
#include "canlib/mcp2515/mcp_2515.h"
#include "platform.h"
#include <xc.h>
#include <stdbool.h>
#include <libpic30.h>

//Set up pin registers
void init_pins()
{
    
    // Enable global interrupt
    INTCON2bits.GIE = 1;

    //LEDs off at startup
    LATBbits.LATB12 = 0;
    LATBbits.LATB13 = 0;
    LATBbits.LATB14 = 0; 

    //set LEDs as outputs
    TRISBbits.TRISB12 = 0; //BLUE D5 
    TRISBbits.TRISB13 = 0; //RED D4
    TRISBbits.TRISB14 = 0; //WHITE D3
    

    //disable all analogs that don't give me errors
    ANSELAbits.ANSA4 = 0; //SET AS PIC_RX as digital (analog by default)
    ANSELBbits.ANSB0 = 0; //37V EN
    ANSELBbits.ANSB8 = 0; 
    
    //CAN stuff
    TRISBbits.TRISB4 = 0; //set CANTX as output
    TRISAbits.TRISA4 = 1; //set CANRX as input

    ANSELAbits.ANSA4 = 0; //SET AS PIC_RX as digital (analog by default)
    RPINR26bits.C1RXR = 0b0010100; //set CAN input to pin RP20/RA4/pin12
    RPOR1bits.RP36R = 0b1110; //set CAN output to pin RP36/RB4

    //MCP2151 CLK stuff
    REFOCONbits.ROON = 0; //disable reference oscillator
    TRISBbits.TRISB11 = 0; //set REFCLKO as output
    RPOR4bits.RP43R = 0b110001; //set reference clock output to pin 11 RP36
    
    REFOCONbits.ROSSLP = 1; //continue to run in sleep
    REFOCONbits.ROSEL = 1; //use reference clk
    REFOCONbits.RODIV = 0x0; //no clk divider

    REFOCONbits.ROON = 1; //enable reference oscillator

    TRISBbits.TRISB10 = 1; //CAN_INT from MCP2515
    RPINR0bits.INT1R = 0b0101010; // assign interrupt 1 to RP42 (RB10)
    INTCON2bits.INT1EP = 1; // interrupt 1 on negative edge
    IEC1bits.INT1IE = 0; // disable interrupt 1
    IFS1bits.INT1IF = 0; // clear interrupt 1

    //Papa board power peripherals
    TRISBbits.TRISB0 = 0; //set 37V EN as output
    LATBbits.LATB0 = 0; //initially disable 37VEN

    TRISBbits.TRISB1 = 1; //set V_SENSE as input
    TRISBbits.TRISB15 = 0; //set MAMA_PWR_EN as output
    PORTBbits.RB15 = 0; //initially disable MAMA_PWR_EN

    TRISAbits.TRISA0 = 1; //set BAT_CURR_AMP as input
    TRISAbits.TRISA1 = 1; //set 3V3_CURR_AMP as input

    //SPI STUFF
    TRISBbits.TRISB5 = 0; //set CS2 (sd card) as output
    TRISBbits.TRISB6 = 0; //set CS1 MCP2515 as output
    LATBbits.LATB6 = 1; //drive CS 1 line high
    LATBbits.LATB5 = 1; //drive CS 2 line high
    
    TRISBbits.TRISB7 = 0; //set SCK as output
    TRISBbits.TRISB8 = 1; //set MISO as input
    TRISBbits.TRISB9 = 0; //set MOSI as output
    
    REFOCONbits.ROON = 1; //enable reference oscillator

    
}

//Get running off of the external oscillator.
//Currently set to make Fosc 64MHz, which means 32M instructions per second.
void init_oscillator()
{
    //The following register settings look wrong for what the comment says
    //They are actually correct, read the datasheet if you don't believe me!
    
    //divide input frequency (12MHz) by 3 to get 4MHz
    CLKDIVbits.PLLPRE = 0x01;

    //multiply the 4MHz by 64 to get 256MHz
    PLLFBDbits.PLLDIV = 62;

    //divide the 256MHz by 4 to get a 64M Fosc
    CLKDIVbits.PLLPOST = 0x01;

    //disable clock dozing, because we currently don't care about power draw
    CLKDIVbits.DOZEN = 0;

    /*
     * This upcoming clock switch thing is annoying. For details on what this
     * assembly does, check out this datasheet
     * http://ww1.microchip.com/downloads/en/DeviceDoc/39700c.pdf
     */

    //to unlock NOSC, need to write 0x9A, 0x78, and NOSC to OSCCONH in three
    //consecutive instructions
    volatile register uint8_t *w = &OSCCONH;
    register uint8_t x = 0x78;
    register uint8_t y = 0x9A;
    //desired NOSC value is lower nibble of z, 3
    register uint8_t z = 0x73;
    //three consecutive writes
    *w = x;
    *w = y;
    *w = z;
    //to perform the clock switch, we need to unlock OSCCONL and write 1 to the
    //lowest bit of OSCCONL. These need to be three consecutive instructions.
    //The two unlock writes are 0x46 and 0x57
    w = &OSCCONL;
    x = 0x46;
    y = 0x57;
    z = 0x01;
    //three consecutive writes
    *w = x;
    *w = y;
    *w = z;

    //wait until we're running off of the external clock
    while (OSCCONbits.COSC != 0x03) {}
}

/*
 * setup timers 2 and 3 to form a 32-bit timer that does not fire an interrupt
 */
void init_timers()
{
    //continue while idle
    T2CONbits.TSIDL = 0;
    //disable gated time accumulation
    T2CONbits.TGATE = 0;
    //do no prescaling (drive oscillator with Fp)
    T2CONbits.TCKPS = 0;
    //set as 32 bit timer
    T2CONbits.T32 = 1;
    //use  Fp as input
    T2CONbits.TCS = 0;
    //Clear out the counts
    TMR2 = 0;
    TMR3 = 0;
    //divide the input frequency by 64
    T2CONbits.TCKPS = 2;

    //enable timer2
    T2CONbits.TON = 1;
}

void init_system()
{
    //initialize the oscillator so we're running faster
    init_oscillator();
    //initialize the pins first so we can use the LEDs to tell us if init fails
    init_pins();

    //start timers
    init_timers();
}

//OLD CS1 FUNCTION
/*void cs1_mcp_drive(uint8_t state)
{
     LATBbits.LATB6 = state;
*/

void init_spi()
{
    //enable spi module 2 as master mode
    SPI2CON1bits.DISSCK = 0; //enable sck
    SPI2CON1bits.DISSDO = 0; //enable SDO
    SPI2CON1bits.MODE16 = 0; //8 bit things
    SPI2CON1bits.SMP    = 0; //sample at middle of data time
    SPI2CON1bits.CKE    = 0; //switch output on rising edge of SCK
    SPI2CON1bits.SSEN   = 0; //we are not in slave mode, leave CS GPIO
    SPI2CON1bits.CKP    = 1; //idle clock level high.
    SPI2CON1bits.MSTEN  = 1; //use master mode
    SPI2CON1bits.SPRE   = 6; //secondary prescale 2:1
    //SPI2CON1bits.PPRE   = 0x01; //primary prescale 16:1
    SPI2CON1bits.PPRE  = 3; //primary prescale 1:1
    SPI2CON2bits.FRMEN  = 0; //don't use framed mode
    SPI2CON2bits.SPIBEN = 0; //use standard mode, not enhanced mode

    //set SCK output to RP39, and input to RI32 (both must be set)
    RPOR2bits.RP39R = 0x09; //setting RPn tied to SPI2
    RPINR22bits.SCK2R = 0b0100000;//that's setting the clock input to RPI32
    
    //set MOSI output to RP41 (RB9)
    RPOR3bits.RP41R = 0x08;
    //set MISO input to RP40 (RB8)
    RPINR22bits.SDI2R = 0b0101000;
    
    //Already done in init_pins()
    /*set CS_1 as GPIO output on RB6. Start high. RP38
    TRISBbits.TRISB6 = 0;
    LATBbits.LATB6 = 1;
    //RPOR2bits.RP38R = 0b001011; //slave select
    //set CS_2 as GPIO output on RB5. Start high. RP37
    TRISBbits.TRISB5 = 0;
    LATBbits.LATB5 = 1;
    RPOR2bits.RP37R = 0b001011; //slave select*/

    //enable spi module 1
    SPI2STATbits.SPIEN = 1;
}

void init_peripherals()
{
    // initialize CAN first, so that we don't miss incoming messages
    init_can_syslog();

    // Wait 20ms before initializing SD card, to let it boot up
    __delay32(20 * (FCY / 1000));
    init_spi();
    init_sd_card2();
 
}

## Commit log (part)

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2020-04-02 Added updated library
2020-04-17 Initial schematics for CCD & RADFET
2020-05-24 mudered instrumentation board...hopefully
2020-06-03 Modify folder names
2020-07-05 Added values - may not be final
2020-07-16 Made changes requested by Chamath & added connectors and DC/DC converter
2020-08-16 Murdered the amplifier & changed transimpedance gain. Still no idea how to check values
2020-09-09 Reduced voltage input to OP-AMP. Schematic should be ready to push to master
2020-09-18 Changed DC/DC converter + Updated annotations
2020-10-07 Added second photodiode in parallel and finalized resistor values
2020-12-01 Finished routing & cleaned up PCB Layout
2020-12-23 firmware init
2020-12-23 doc and config changes
2021-01-01 renamed folder and file names
2021-01-01 Updated schematic to reflect progress with testing
2021-01-01 cleaned up files
2021-01-07 removed valve nonsense
2021-01-07 fixed inputs to battery management schematic
2021-01-10 modified schematic a git to remove some messiness
2021-01-10 annotated schematic symbols
2021-01-10 modified SM74611 wiring as per Adam's suggestions
2021-01-10 added a 3v3 pilot LED
2021-01-12 removed SD breakout, put programming header in top sheet
2021-02-04 renamed net labels to be shorter and match hierarchical labels
2021-02-04 removed connection from the megasheet to 5V and GND
2021-02-04 fixed a minor connection problem
2021-02-06 Added interrupt infrastructure
2021-02-08 Testing changes
2021-02-13 renamed whole folder to Papa_Board from Main_Controller_Board
2021-02-21 reset registry
2021-02-21 moving heavy computation out of interrupt
2021-03-14 removed pilot LEDs
2021-03-14 moved power management stuff to battery_management sheet
2021-03-14 removed some of CAN power connections
2021-03-20 added fuses to batteries
2021-03-20 changed the SPI connectors to only connect to 5V
2021-03-30 redid power with Webench to match 5V output at a max 3A (power budget predicts 2.1A)
2021-04-01 removed old pdfs
2021-04-03 regenerated pdf
2021-04-06 Mostly functional Detector Board Circuit
2021-04-06 fixed typo
2021-04-10 added diode to power source to prevent current from going the wrong way
2021-04-18 added a new power_supply library with new fixed-voltage regulator
2021-04-27 Added power management schematic
    Added power management, changed power management input voltage to 12V, and added new symbol to library.
2021-05-01 added 12V regulator and a 3rd 12V connection
2021-05-01 Revert "Added PDF schematic"
    This reverts commit acb222c7c3d3376f23fd3c6c012a1e1b72ca746a.
2021-05-02 Updated circuit and added pdf
2021-05-07 Edited power management sheet
2021-05-07 Updated power management sheet, added missing PIC18 sheet
2021-05-08 Fixed 5V CAN connection
    Removed second 12V connector, replaced with 5V
2021-05-09 Moved power supplies to papa board, updated PDF
    Removed power management sheet, moved schematic to papa board
2021-05-11 Fixed connectors
2021-05-12 Made updated detector circuit - Needs a lot of clean up
2021-05-13 formatting and comments added
2021-05-15 Updated battery management sheet, battery connector, and lots of other smaller changes
2021-05-17 Fixed cutoff frequency value
    should be 1.6 kHz not 1.6 Hz
2021-05-19 Added LED
2021-05-21 Replaced 36V LDO, fixed system sleep control, moved 4.7V LDO to mama board, updated PDF
2021-05-22 Move 36V LDO to mama board
2021-05-22 Cleaned up schematic, updated battery & external connectors. Needs updates to mama board connectors
2021-05-23 Implement minor review changes (see description)
    - added .sch-bak to gitignore
    - added PIC and MCP2515 to non-backup library
    -cleaned up schematic
2021-05-25 Add PIC18 and transceiver
    still needs connector to CAN bus
2021-05-25 Add low pass filters
2021-05-26 Add missing 12V line to minisensor
2021-05-31 Remove unnecessary files, update fuse values, fix debugging LED arrangement, other minor changes
2021-06-03 Fix system sleep control, clean up schematic, update pdf
2021-06-05 Finished overall schematic - ERC errors that need to be fixed
2021-06-06 Addressed Randy's comments
2021-06-06 removed library reference in global library
2021-06-08 Add proper level shifter, update pdf
2021-06-09 assigned footprints started layout, still some footprint issues to fix
2021-06-10 Fix custom2 lib inclusion
2021-06-11 Accidentally added some footprints thinking it was proto WHOOOPS
2021-06-11 Fixed symbol issues, assigned footprints
2021-06-11 Replace 5V regulator, replace inductor, fix symbols, LED resistors, and other small changes
    everything that was running on 5V is now running on 5.3V
2021-06-11 Add TPS61175-PWP footprint
2021-06-12 put in (hopefully) correct battery footprints, added board cut-out & randomly sized & placed holes, stared layout
2021-06-12 finished ~papa board~ half of the layout
2021-06-13 Add crystal and harwin footprints, other minor changes, update pdf
2021-06-13 Finished first version of layout, fixed some small mistakes on schematic
2021-06-13 Add board outline and hole placements, position connectors, fix some footprints
2021-06-14 fixed up silkscreens, re-added detector circuit, added more labels
2021-06-15 fixed 5V regulator foot print, re-routed and started routing 36V regulator
2021-06-15 did sm'ore routing, letting artem do some stuff :((
2021-06-16 Do Substantial Portion of Routing
    Route most major blocks for mama and power circuitry. Most that remains is power plane management. Some polygons also look nicer now.
2021-06-16 added back hierarcal sheet that was accidentally deleted
2021-06-16 Add units, fix CS line voltage divider, update PDF
2021-06-16 mostly finished detector circuit routing, pushing so ppl can look at it while i finish the rest
2021-06-17 Move 3.3V regulator closer to microSD card
2021-06-17 did sm'ore routing, put detector circuit on the other side of pcb flipped it around for better layout
2021-06-18 More routing, replace custom power symbols with net labels (for routing purposes)
2021-06-19 complete header and source function skeleton
2021-06-20 More routing, need to fix DRC warnings
2021-06-20 Fixed some small silkscreen things, made mounting holes mounting holes
2021-06-20 added missing connection and fixed 1 (1) weird trace length
2021-06-22 Addressed Jack's Comments, got half of Chamath's comments addressed
2021-06-22 Finished Addressing chamath's Reviews
2021-06-23 edit main and add timer files
2021-06-23 redo everything
2021-06-24 continue adding init and get function for adc
2021-06-24 Address Lana's comments
2021-06-25 project cleanup
2021-06-26 Finish layout again, fix DRC errors and warnings
2021-06-26 Clean up via placement, add more labels on silkscreen
2021-06-27 Made polygons thermal, removed pours from under inductors, generated gerbers, did more silkscreen fine tuning
2021-06-28 Added 2nd kind of transimpedance amplifier
2021-06-29 edit pin registers and work on pin interrupt handler
2021-06-29 Address Lana and Chamath's comments, still need to better organize the vias
2021-06-29 add comments
2021-06-30 can message sending
2021-06-30 updated gerbers, 'cause i forgot
2021-07-01 Move 3V3 line and rocket CAN traces
2021-07-03 Address Lance's comments, change microSD voltage divider resistor values (in-stock resistors)
2021-07-04 remove led
2021-07-05 Generate gerber files
2021-07-06 made silkscreen less ugly
2021-07-07 Add more dimensions
2021-07-08 finished layout for testing infastructure, now detatchable from detector circuit for easy swappability
2021-07-10 almost finished 2/4 of swappable detector circuits, im sorry i want to sleep. will continue the grind in the morning
2021-07-10 Finished 2nd swappable circuit layout
2021-07-10 Fixedoverlapping copper areas & added name
2021-07-12 removed files I forgot to remove the first time
2021-07-12 edits to resolve errors
2021-07-13 Addressed Zachary's review, fixed some silkscreen issues and moved some components further apart. Added project information to README
2021-07-13 Add canhw.lib to the payload project
2021-07-13 Addressed Zachary's review, re-made gerbers
2021-07-15 Update date on silkscreen
2021-07-15 Added dates, fixed some small silkscreen issues generated final gerbers GOOD TO FUCKING GO
2021-08-23 minor changes based on reviews
2021-09-20 Fix one missing wire, update pdf + gerbers
2021-09-30 updated library filepaths
2021-10-11 Changed values to what was functional on protoboard
2021-10-13 Assign footprints
2021-10-15 Switch header positions
2021-10-15 Add the onboarding document
2021-10-16 Route components - 1/2 board complete
2021-10-28 Address Lana's schematic review
2021-10-30 Address Lana + Jack's comments on schematic, rename files to "papa board"
2021-11-02 Clean up silkscreen
2021-11-05 add small changes
2021-11-16 Update comparators, move pins for better mechanical fit in cubesat
2021-11-19 Minor fixes, improve via placement
2021-11-25 Minor fixes, generate gerbers, update PDF
2022-01-03 port logger board code
2022-01-15 make minor changes
2022-01-17 add macro for turning on mamaboard (setting pin b15 low)
2022-01-30 modify .gitignore to add project files
2022-02-03 Update gerbers to the format JLC likes
2022-04-20 Add mama.h
2022-04-20 Get the pin interrupts to work :)
2022-04-21 Change ADC interrupts to polling triggered by comparator
2022-05-07 Papa board revision changes (see desc)
    - simplify power nets
    - change 5.3V buck to 5V
    - change 5V buck to b always enabled
    - change input voltage to dspic33
    - remove live telemetry connector
    - add load resistor to 37V boost to keep operation in PWM mode
2022-05-09 updated schematic to reflect old papa board w/pic18k26f83
2022-05-11 Finish changes to PCB layout, clean up and simplify VCC layer
2022-05-12 Connect TPS61175 NC pin to GND and update date on silkscreen
2022-05-16 switched all files to new kicad
2022-05-20 Finish revisions: replace mama sleep circuit with power switch IC, fix unconnected nets, ground mounting holes, add lots of stitching vias
2022-05-20 update SD voltage div
2022-05-20 updated board layout, absolute clusterfuck but seriously need to pay attention to class
2022-05-21 Finish PCB layout updates
2022-05-21 fixed drc errors
2022-05-21 Address Zach + Jacks review, move mounting holes to fit logger, update pdf
2022-05-22 made last fixes & revision, generated gerbers
2022-05-22 Update L2 footprint, silkscreen adjustments
2022-05-22 addressed joe's concerns
2022-05-28 ADC still, still doesn't work
2022-05-31 experimental setup for reference clk
2022-06-03 Respond to activate mamaboard message, fix various build issues
2022-06-03 made LEDs work, and heartbeat mama on/off with LED for test
2022-06-04 mostly made a mess of things, but hopefully fixed pin mappings
2022-06-04 run check_rocketcan_msg from interrupt
2022-06-05 Add ADC configuration
2022-06-06 Fix minor build errors
2022-06-07 hopefully fixed SPI, and updated system config
2022-06-10 added extensive error checking, removed random constants from ADC
2022-06-14 moved checking rocketcan out of interrupt handler
2022-06-17 code changed but untested
2022-06-17 power lines and voltage health check functional
2022-06-18 working-ish mama code
2022-06-21 Rewrite SPI driver to make use of MCC genereated SPI modules
2022-06-21 Update board ID
2022-06-21 update board ID, but on another branch
